# Keil uVision project stm32f1_register.uvprojx, settings and files
target Project (6240000::V6.24::ARMCLANG)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f1_register
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\Driver;.\Src
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Src
    ./Src/: main.c main.h
  group Driver
    ../../Driver/: rcc.c rcc.h gpio.c gpio.h afio.c afio.h exti.c exti.h TYPE.h tim.c tim.h adc.c adc.h uart.c uart.h dma.h can.c can.h dma.c
software components: CMSIS:CORE 6.2.0, Device:Startup 1.0.0
